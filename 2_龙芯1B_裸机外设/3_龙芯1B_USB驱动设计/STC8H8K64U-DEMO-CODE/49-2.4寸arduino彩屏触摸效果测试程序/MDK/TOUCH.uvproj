# Keil uVision project TOUCH.uvproj, settings and files
target TOUCH (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: TOUCH +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Device;..\Libraries
  group User
    ../User/: Main.c
  group Libraries
    ../Libraries/: delay.c sys.c
  group Device
    ../Device/: hc595.c led8.c tftlcd.c touch.c adc.c eeprom.c
